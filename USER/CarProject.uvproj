# Keil uVision project CarProject.uvproj, settings and files
target CAR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CarProject +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\uart4;..\SYSTEM\timer;..\USER;..\HARDWARE\LED;..\HARDWARE\TFT;..\HARDWARE\ENCODER;..\HARDWARE\ESP8266;..\HARDWARE\FIND;..\HARDWARE\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c pid.c control.c
  group HARDWARE
    ../HARDWARE/TFT/: GUI.c Lcd_Driver.c QDTFT_demo.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/FIND/: find.c
    ../HARDWARE/MOTOR/: motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer2.c timer3.c timer4.c timer5.c timer6.c timer8.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c
